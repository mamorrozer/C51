/**
 * @file nixie.c
 * @brief 数码管显示驱动模块
 * @version 1.0
 *
 * 功能说明：
 * - 提供单个数码管定点显示功能
 * - 提供音乐播放进度专用显示功能
 * - 支持0~100的进度百分比显示
 */

#include <REGX52.H>
#include <delay.h>

/**
 * 数码管段码表
 * 共阴数码管标准段码，对应数字0~9
 * 格式：0x3F(0), 0x06(1), 0x5B(2), 0x4F(3), 0x66(4),
 *       0x6D(5), 0x7D(6), 0x07(7), 0x7F(8), 0x6F(9)
 */
unsigned char NixieTable[] = {0x3F, 0x06, 0x5B, 0x4F, 0x66, 0x6D, 0x7D, 0x07, 0x7F, 0x6F};

/**
 * @brief 单个数码管定点显示函数
 * @param Location 数码管位置（1~8）
 * @param Number 要显示的数字（0~9）
 * @return 无
 *
 * 工作原理：
 * 1. 通过P2_2、P2_3、P2_4控制3-8译码器选择数码管位置
 * 2. 通过P0口输出段码，控制数码管显示的数字
 */
void Nixie(unsigned char Location, Number)
{
	// 根据位置，输出对应的位选信号，选择哪一个数码管点亮
	switch(Location)
	{
		case 1: P2_4 = 1; P2_3 = 1; P2_2 = 1; break;  // 选中第1位数码管
		case 2: P2_4 = 1; P2_3 = 1; P2_2 = 0; break;  // 选中第2位数码管
		case 3: P2_4 = 1; P2_3 = 0; P2_2 = 1; break;  // 选中第3位数码管
		case 4: P2_4 = 1; P2_3 = 0; P2_2 = 0; break;  // 选中第4位数码管
		case 5: P2_4 = 0; P2_3 = 1; P2_2 = 1; break;  // 选中第5位数码管
		case 6: P2_4 = 0; P2_3 = 1; P2_2 = 0; break;  // 选中第6位数码管
		case 7: P2_4 = 0; P2_3 = 0; P2_2 = 1; break;  // 选中第7位数码管
		case 8: P2_4 = 0; P2_3 = 0; P2_0 = 0; break;  // 选中第8位数码管
	}
	
	// 输出段码 → 让选中的数码管显示对应数字
	P0 = NixieTable[Number];
}

/**
 * @brief 音乐播放进度专用显示函数
 * @param a 进度百分比（0~100）
 * @param i 动态显示标志位（0=显示十位，1=显示个位）
 * @return 无
 *
 * 工作原理：
 * 1. 当进度小于10时，只在第1位数码管显示个位数
 * 2. 当进度大于等于10时，通过动态扫描显示：
 *    - i=0：在第1位数码管显示十位数
 *    - i=1：在第2位数码管显示个位数
 * 3. 配合定时器1中断，实现两位数码管的动态显示
 */
void nixie_display(unsigned int a, unsigned char i)
{
	// 进度是个位数（0~9）：只显示第一位数码管
	if(a < 10)
	{
		Nixie(1, a);
	}
	// 进度是两位数：显示十位（第1位数码管）
	else if(a >= 10 && i == 0)
	{
		Nixie(1, a / 10);  // 取整得到十位数
	}
	// 进度是两位数：显示个位（第2位数码管）
	else if(a >= 10 && i == 1)
	{
		Nixie(2, a % 10);  // 取余得到个位数
	}
}